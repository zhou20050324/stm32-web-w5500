# Keil uVision project AutoProject.uvprojx, settings and files
target Target 1 (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: STM32F103C8 STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.2.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: AutoProject
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\Start;.\User;.\Ethernet;.\Ethernet\W5500;.\TCP;.\UDP;.\Web;.\Web\httpServer
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group Start
    ./Start/: core_cm3.c core_cm3.h startup_stm32f10x_md.s stm32f10x.h system_stm32f10x.c system_stm32f10x.h
  group User
    ./User/: main.c Delay.c dma1.c usart1.c adc1.c spi.c can.c led.c beep.c software_w25q64.c bkp.c
  group Ethernet
    ./Ethernet/: eth.c socket.c wizchip_conf.c
    ./Ethernet/W5500/: w5500.c
  group TCP
    ./TCP/: tcp.c
  group UDP
    ./UDP/: udp.c
  group Web
    ./Web/: web_server.c
    ./Web/httpServer/: httpServer.c httpParser.c httpUtil.c
